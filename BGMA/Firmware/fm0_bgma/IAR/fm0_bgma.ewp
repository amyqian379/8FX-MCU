# IAR project fm0_bgma.ewp, settings and files
configuration S6E1C32_Release (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\common; ..\cmsis\include; ..\source; ..\source\config; ..\source\application; ..\source\epcs; ..\source\system; ..\source\usb\driver; ..\source\usb\device; ..\source\usb\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fm0_bgma.srec
  ILINK.IlinkOutputFile: fm0_bgma.out
  ILINK.IlinkIcfFile: config\s6e1c32_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E1C32_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptStrategy: 0
  group (top)
    ../: README.md
  group application
    ../source/application/: bgma_app.c bgma_app.h bgma_misc.c dbg_print.c dbg_print.h hostif.c LPCdef.h systick.c UARTcomm.c UARTio.c USBcomm.c version.h
  group common
    ../common/: system_s6e1c3.c
  group config
    ../source/config/: iomux.c
  group epcs
    ../source/epcs/: epcs_app.c epcs_app.h epcs_common.c epcs_common.h epcs_config.h epcs_usbio.c epcs_usbio.h epcs_vendor.c epcs_vendor.h
  group source
    ../source/: config.h debug.c debugUART.c debugUART.h main.c mcu.h
    ./: startup_s6e1c3.s
  group usb
    ../source/usb/driver/: usb.c usb.h usbconst.h usbdevice.c usbdevice.h usbethernetclock.c usbethernetclock.h
    ../source/usb/config/: UsbConfig.c usbconfig.h usbdescriptors.h usbdevicehw.h
    ../source/usb/device/: UsbDeviceVendor.c UsbDeviceVendor.h
